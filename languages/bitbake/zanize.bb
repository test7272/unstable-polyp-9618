python do_hello() {
    bb.plain("Hello World!")
}
addtask do_hello
